<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run</key><value>run_stop</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>BpS2</value></param>
<param><key>value</key><value>int(math.log(M2,2))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>BpS4</value></param>
<param><key>value</key><value>int(math.log(M4,2))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>BpS8</value></param>
<param><key>value</key><value>int(math.log(M8,2))</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Delay</value></param>
<param><key>value</key><value>6</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Timing (Clock Recovery)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>Sps-1</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Delay_mpam</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>Menu@0:2,0,1,1</value></param>
<param><key>label</key><value>Retraso a T3</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>256</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>EsN0max</value></param>
<param><key>value</key><value>50.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>EsN0min</value></param>
<param><key>value</key><value>0.</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M2</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M4</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M8</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N_snr</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rb2</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rb4</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rb8</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rs2</value></param>
<param><key>value</key><value>Rb2/BpS2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rs4</value></param>
<param><key>value</key><value>Rb4/BpS4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Rs8</value></param>
<param><key>value</key><value>Rb8/BpS8</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>run_stop</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Inicial/Parar</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>Menu</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>label0</key><value>Info</value></param>
<param><key>label1</key><value>Modulacion</value></param>
<param><key>label2</key><value>Canal</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>1.</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0</value></param>
<param><key>const</key><value>1.</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0_0</value></param>
<param><key>const</key><value>1.</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>1000000</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>b_BERTool</key>
<param><key>id</key><value>b_BERTool_0_0_0</value></param>
<param><key>EsN0max</key><value>EsN0max</value></param>
<param><key>EsN0min</key><value>EsN0min</value></param>
<param><key>N_snr</key><value>N_snr</value></param>
<param><key>Rs</key><value>Rs2</value></param>
</block>
<block>
<key>b_BERTool</key>
<param><key>id</key><value>b_BERTool_0_0_0_0</value></param>
<param><key>EsN0max</key><value>EsN0max</value></param>
<param><key>EsN0min</key><value>EsN0min</value></param>
<param><key>N_snr</key><value>N_snr</value></param>
<param><key>Rs</key><value>Rs4</value></param>
</block>
<block>
<key>b_BERTool</key>
<param><key>id</key><value>b_BERTool_0_0_0_0_0</value></param>
<param><key>EsN0max</key><value>EsN0max</value></param>
<param><key>EsN0min</key><value>EsN0min</value></param>
<param><key>N_snr</key><value>N_snr</value></param>
<param><key>Rs</key><value>Rs8</value></param>
</block>
<block>
<key>b_u_M_PAM_bb</key>
<param><key>id</key><value>b_u_M_PAM_bb_0</value></param>
<param><key>M</key><value>M2</value></param>
</block>
<block>
<key>b_u_M_PAM_bb</key>
<param><key>id</key><value>b_u_M_PAM_bb_0_0</value></param>
<param><key>M</key><value>M4</value></param>
</block>
<block>
<key>b_u_M_PAM_bb</key>
<param><key>id</key><value>b_u_M_PAM_bb_0_0_0</value></param>
<param><key>M</key><value>M8</value></param>
</block>
<block>
<key>b_u_de_M_PAM_bb</key>
<param><key>id</key><value>b_u_de_M_PAM_bb_0</value></param>
<param><key>M</key><value>M2</value></param>
</block>
<block>
<key>b_u_de_M_PAM_bb</key>
<param><key>id</key><value>b_u_de_M_PAM_bb_0_0</value></param>
<param><key>M</key><value>M4</value></param>
</block>
<block>
<key>b_u_de_M_PAM_bb</key>
<param><key>id</key><value>b_u_de_M_PAM_bb_0_0_0</value></param>
<param><key>M</key><value>M8</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_1</value></param>
<param><key>delay</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_1_0</value></param>
<param><key>delay</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_1_0_0</value></param>
<param><key>delay</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_inputs</key><value>3</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>e_VCO_fase_fc_0</value></param>
<param><key>_source_code</key><value>
import numpy as np
from gnuradio import gr


class blk(gr.sync_block):  
    """Done by Homero Ortega Boada. Es un VCO dos entradas: 
	in0 para manipular la fase, in1 para manipular la 
	magnitud. En el fondo es el equivalente a un generador
	de una senal exponencial compleja. Sobre la configuracion:
	cada valor de la senal en in0 es interpretada como la fase
	deseada en radianes. cada valor de in0, es la magnitud deseada"""

    def __init__(self): 
        gr.sync_block.__init__(self,
            name='e_VCO_fase_fc',
	    in_sig=[np.float32, np.float32],
            out_sig=[np.complex64]
        )
    def work(self, input_items, output_items):
	ph=input_items[0]
	mag=input_items[1]
	out0=output_items[0]
	out0[:] = mag*np.exp(1.j*ph)
	return len(out0)
</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>e_VCO_fase_fc_0_0</value></param>
<param><key>_source_code</key><value>
import numpy as np
from gnuradio import gr


class blk(gr.sync_block):  
    """Done by Homero Ortega Boada. Es un VCO dos entradas: 
	in0 para manipular la fase, in1 para manipular la 
	magnitud. En el fondo es el equivalente a un generador
	de una senal exponencial compleja. Sobre la configuracion:
	cada valor de la senal en in0 es interpretada como la fase
	deseada en radianes. cada valor de in0, es la magnitud deseada"""

    def __init__(self): 
        gr.sync_block.__init__(self,
            name='e_VCO_fase_fc',
	    in_sig=[np.float32, np.float32],
            out_sig=[np.complex64]
        )
    def work(self, input_items, output_items):
	ph=input_items[0]
	mag=input_items[1]
	out0=output_items[0]
	out0[:] = mag*np.exp(1.j*ph)
	return len(out0)
</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>e_VCO_fase_fc_0_0_0</value></param>
<param><key>_source_code</key><value>
import numpy as np
from gnuradio import gr


class blk(gr.sync_block):  
    """Done by Homero Ortega Boada. Es un VCO dos entradas: 
	in0 para manipular la fase, in1 para manipular la 
	magnitud. En el fondo es el equivalente a un generador
	de una senal exponencial compleja. Sobre la configuracion:
	cada valor de la senal en in0 es interpretada como la fase
	deseada en radianes. cada valor de in0, es la magnitud deseada"""

    def __init__(self): 
        gr.sync_block.__init__(self,
            name='e_VCO_fase_fc',
	    in_sig=[np.float32, np.float32],
            out_sig=[np.complex64]
        )
    def work(self, input_items, output_items):
	ph=input_items[0]
	mag=input_items[1]
	out0=output_items[0]
	out0[:] = mag*np.exp(1.j*ph)
	return len(out0)
</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>e_c_p</value></param>
<param><key>_source_code</key><value>import numpy as np
from gnuradio import gr

class blk(gr.sync_block):  
    """Autor: Homero Ortega. Permite obtener la fase de una senal compleja. A diferencia de otros bloques de gnuradio, este entrega valores positivos de fase entre 0 y 2pi. M es el numero de posibles fases discretas que trae la senal"""
    def __init__(self,M=4):  # only default arguments here
        gr.sync_block.__init__(
            self,
            name='Complex to Phase',   # will show up in GRC
            in_sig=[np.complex64],
            out_sig=[np.float32]
        )
	self.M=M
	self.p2=2.*np.pi
	self.p_margen=self.p2/(M*2.)

    def work(self, input_items, output_items):
	fases=np.angle(input_items[0]) # tiene valores negativos
	fases=(fases+self.p_margen +self.p2)% self.p2-self.p_margen
        output_items[0][:] = fases
        return len(output_items[0])
</value></param>
<param><key>M</key><value>M2</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>e_c_p_0</value></param>
<param><key>_source_code</key><value>import numpy as np
from gnuradio import gr

class blk(gr.sync_block):  
    """Autor: Homero Ortega. Permite obtener la fase de una senal compleja. A diferencia de otros bloques de gnuradio, este entrega valores positivos de fase entre 0 y 2pi. M es el numero de posibles fases discretas que trae la senal"""
    def __init__(self,M=4):  # only default arguments here
        gr.sync_block.__init__(
            self,
            name='Complex to Phase',   # will show up in GRC
            in_sig=[np.complex64],
            out_sig=[np.float32]
        )
	self.M=M
	self.p2=2.*np.pi
	self.p_margen=self.p2/(M*2.)

    def work(self, input_items, output_items):
	fases=np.angle(input_items[0]) # tiene valores negativos
	fases=(fases+self.p_margen +self.p2)% self.p2-self.p_margen
        output_items[0][:] = fases
        return len(output_items[0])
</value></param>
<param><key>M</key><value>M4</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>e_c_p_0_0</value></param>
<param><key>_source_code</key><value>import numpy as np
from gnuradio import gr

class blk(gr.sync_block):  
    """Autor: Homero Ortega. Permite obtener la fase de una senal compleja. A diferencia de otros bloques de gnuradio, este entrega valores positivos de fase entre 0 y 2pi. M es el numero de posibles fases discretas que trae la senal"""
    def __init__(self,M=4):  # only default arguments here
        gr.sync_block.__init__(
            self,
            name='Complex to Phase',   # will show up in GRC
            in_sig=[np.complex64],
            out_sig=[np.float32]
        )
	self.M=M
	self.p2=2.*np.pi
	self.p_margen=self.p2/(M*2.)

    def work(self, input_items, output_items):
	fases=np.angle(input_items[0]) # tiene valores negativos
	fases=(fases+self.p_margen +self.p2)% self.p2-self.p_margen
        output_items[0][:] = fases
        return len(output_items[0])
</value></param>
<param><key>M</key><value>M8</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>e_mpam_ph</value></param>
<param><key>_source_code</key><value>import numpy as np
from gnuradio import gr

class blk(gr.sync_block):  
#    """Traduce M_PAM a valores de fase"""
    def __init__(self,M=4):  # only default arguments here
        gr.sync_block.__init__(
            self,
            name='M_PAM to Phase',   # will show up in GRC
            in_sig=[np.int8],
            out_sig=[np.float32]
        )
	self.M=M
	self.p2=2.*np.pi

    def work(self, input_items, output_items):
	#fases=input_items[0]*self.p2/self.M

        output_items[0][:] = input_items[0]*self.p2/self.M
        return len(output_items[0])
</value></param>
<param><key>M</key><value>M2</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>e_mpam_ph_0</value></param>
<param><key>_source_code</key><value>import numpy as np
from gnuradio import gr

class blk(gr.sync_block):  
#    """Traduce M_PAM a valores de fase"""
    def __init__(self,M=4):  # only default arguments here
        gr.sync_block.__init__(
            self,
            name='M_PAM to Phase',   # will show up in GRC
            in_sig=[np.int8],
            out_sig=[np.float32]
        )
	self.M=M
	self.p2=2.*np.pi

    def work(self, input_items, output_items):
	#fases=input_items[0]*self.p2/self.M

        output_items[0][:] = input_items[0]*self.p2/self.M
        return len(output_items[0])
</value></param>
<param><key>M</key><value>M4</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>e_mpam_ph_0_0</value></param>
<param><key>_source_code</key><value>import numpy as np
from gnuradio import gr

class blk(gr.sync_block):  
#    """Traduce M_PAM a valores de fase"""
    def __init__(self,M=4):  # only default arguments here
        gr.sync_block.__init__(
            self,
            name='M_PAM to Phase',   # will show up in GRC
            in_sig=[np.int8],
            out_sig=[np.float32]
        )
	self.M=M
	self.p2=2.*np.pi

    def work(self, input_items, output_items):
	#fases=input_items[0]*self.p2/self.M

        output_items[0][:] = input_items[0]*self.p2/self.M
        return len(output_items[0])
</value></param>
<param><key>M</key><value>M8</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>e_phase</value></param>
<param><key>_source_code</key><value>import numpy as np
from gnuradio import gr

class blk(gr.sync_block):  
#    """Traduce fases a valores de M_PAM y aplica decisor mediante redondeo"""
    def __init__(self,M=4):  # only default arguments here
        gr.sync_block.__init__(
            self,
            name='phase to M_PAM',   # will show up in GRC
            in_sig=[np.float32],
            out_sig=[np.int8]
        )
	self.M=M
	self.p2=2.*np.pi

    def work(self, input_items, output_items):
	mpam_con_ruido=input_items[0]*self.M/self.p2
	mpam_sin_ruido=np.round(mpam_con_ruido)

        output_items[0][:] = mpam_sin_ruido.astype(np.int8)
        return len(output_items[0])
</value></param>
<param><key>M</key><value>M2</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>e_phase_0</value></param>
<param><key>_source_code</key><value>import numpy as np
from gnuradio import gr

class blk(gr.sync_block):  
#    """Traduce fases a valores de M_PAM y aplica decisor mediante redondeo"""
    def __init__(self,M=4):  # only default arguments here
        gr.sync_block.__init__(
            self,
            name='phase to M_PAM',   # will show up in GRC
            in_sig=[np.float32],
            out_sig=[np.int8]
        )
	self.M=M
	self.p2=2.*np.pi

    def work(self, input_items, output_items):
	mpam_con_ruido=input_items[0]*self.M/self.p2
	mpam_sin_ruido=np.round(mpam_con_ruido)

        output_items[0][:] = mpam_sin_ruido.astype(np.int8)
        return len(output_items[0])
</value></param>
<param><key>M</key><value>M4</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>e_phase_0_0</value></param>
<param><key>_source_code</key><value>import numpy as np
from gnuradio import gr

class blk(gr.sync_block):  
#    """Traduce fases a valores de M_PAM y aplica decisor mediante redondeo"""
    def __init__(self,M=4):  # only default arguments here
        gr.sync_block.__init__(
            self,
            name='phase to M_PAM',   # will show up in GRC
            in_sig=[np.float32],
            out_sig=[np.int8]
        )
	self.M=M
	self.p2=2.*np.pi

    def work(self, input_items, output_items):
	mpam_con_ruido=input_items[0]*self.M/self.p2
	mpam_sin_ruido=np.round(mpam_con_ruido)

        output_items[0][:] = mpam_sin_ruido.astype(np.int8)
        return len(output_items[0])
</value></param>
<param><key>M</key><value>M8</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1</value></param>
<param><key>note</key><value>2-PAM = BINARY</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_0</value></param>
<param><key>note</key><value>BPSK</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_0_0</value></param>
<param><key>note</key><value>QPSK</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_0_0_0</value></param>
<param><key>note</key><value>8-PSK</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_1</value></param>
<param><key>note</key><value>4-PAM</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_1_1_0</value></param>
<param><key>note</key><value>8-PAM</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>INSTRUMENTOS</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>alpha1</key><value>1</value></param>
<param><key>label1</key><value>"B-PSK"</value></param>
<param><key>width1</key><value>6</value></param>
<param><key>label2</key><value>"QPSK"</value></param>
<param><key>width2</key><value>6</value></param>
<param><key>label3</key><value>"8PSK"</value></param>
<param><key>width3</key><value>6</value></param>
<param><key>name</key><value>"Curva de BER"</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>N_snr</value></param>
<param><key>x_axis_label</key><value>"Es/No [dB]"</value></param>
<param><key>x_start</key><value>EsN0min</value></param>
<param><key>x_step</key><value>(EsN0max-EsN0min)/float(N_snr)</value></param>
<param><key>x_units</key><value>"dB"</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-5</value></param>
<param><key>y_axis_label</key><value>"logPe"</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>T3_2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0</value></param>
<param><key>stream_id</key><value>T3_4</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_0</value></param>
<param><key>stream_id</key><value>T4_2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_0_0</value></param>
<param><key>stream_id</key><value>R4_2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_0_0_0</value></param>
<param><key>stream_id</key><value>R4_4</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_0_0_0_0</value></param>
<param><key>stream_id</key><value>R4_8</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_0_1</value></param>
<param><key>stream_id</key><value>T4_4</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_0_1_0</value></param>
<param><key>stream_id</key><value>T4_8</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_3</value></param>
<param><key>stream_id</key><value>R3_2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_3_0</value></param>
<param><key>stream_id</key><value>R3_4</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_3_1</value></param>
<param><key>stream_id</key><value>R3_8</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_3_2</value></param>
<param><key>stream_id</key><value>R2_2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_3_2_0</value></param>
<param><key>stream_id</key><value>R2_4</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_3_2_0_0</value></param>
<param><key>stream_id</key><value>R2_8</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_1</value></param>
<param><key>stream_id</key><value>T3_8</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_2</value></param>
<param><key>stream_id</key><value>T2_2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0_0</value></param>
<param><key>stream_id</key><value>R2_2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0_0_0</value></param>
<param><key>stream_id</key><value>T2_2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0_0_0_0</value></param>
<param><key>stream_id</key><value>T2_2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0_0_0_0_0</value></param>
<param><key>stream_id</key><value>T2_2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0_0_1</value></param>
<param><key>stream_id</key><value>R2_4</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0_0_1_0</value></param>
<param><key>stream_id</key><value>R2_8</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>R4_2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_0</value></param>
<param><key>stream_id</key><value>T4_2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_0_0</value></param>
<param><key>stream_id</key><value>T4_4</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_0_0_0</value></param>
<param><key>stream_id</key><value>T4_8</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_1</value></param>
<param><key>stream_id</key><value>R4_4</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2_1_0</value></param>
<param><key>stream_id</key><value>R4_8</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>wform</value></param>
<param><key>source_code</key><value>import math
import numpy
#######################################################
##        Hecho por Homero Ortega Boada              ##
##        comdiguis@saber.uis.edu.co                 ##
##     Universidad Industrial de Santander           ##
#######################################################

#######################################################
##               Forma rectangular                   ##
#######################################################                       
def rect(Sps):
    return Sps*[1.,]

#######################################################
##               Forma de Nyquist                    ##
#######################################################                       
def nyq(Sps,ntaps):
    n=numpy.linspace(-int(ntaps/2), int(ntaps/2-1),ntaps)
    h=numpy.sinc(n/Sps)
#    return h/numpy.amax(h)
    return h
#######################################################
##               Forma Coseno Alzado                 ##
#######################################################                       
def rcos(Sps,ntaps,beta):
    if beta==0:
        h=nyq(Sps,ntaps)
    else:
        h=ntaps*[0,]
        for n in range(ntaps):
            k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector
            if abs(k)==Sps/(2.*beta):
                h[n]=numpy.sinc(1./(2.*beta))*math.pi/4.
            else:
                h[n]=numpy.sinc(k/Sps)*math.cos(beta*k*math.pi/Sps)/(1.-(2.*beta*k/Sps)**2)                
    Amp=numpy.amax(h)
    return h/Amp
#######################################################
##            Forma Raiz de Coseno Alzado            ##
#######################################################                       

def rrcos(Sps,ntaps,beta):
    if beta==0:
        h=nyq(Sps,ntaps)
    else:
        h=ntaps*[0,]
        beta4=4.*beta
        for n in range(ntaps):
            k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector
            if k==0:
                h[n]=1+beta*(4./math.pi-1.)
            elif abs(k)==Sps/beta4:
                ha=(1.+2./math.pi)*math.sin(math.pi/beta4)
                hb=(1.-2./math.pi)*math.cos(math.pi/beta4)
                h[n]=(ha+hb)*beta/math.sqrt(2.)
            else:
                ks=k/Sps
                kspi=math.pi*ks
                Num=math.sin(kspi*(1-beta))+beta4*ks*math.cos(kspi*(1+beta))
                Den=kspi*(1.-(beta4*ks)**2)
                h[n]=Num/Den                
    Amp=numpy.amax(h)
    return h/Amp
</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>e_VCO_fase_fc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0</source_block_id><sink_block_id>e_VCO_fase_fc_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0_0</source_block_id><sink_block_id>e_VCO_fase_fc_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>b_u_M_PAM_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>b_u_M_PAM_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>b_u_M_PAM_bb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>virtual_sink_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_BERTool_0_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_BERTool_0_0_0</source_block_id><sink_block_id>virtual_sink_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_BERTool_0_0_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>b_BERTool_0_0_0_0</source_block_id><sink_block_id>virtual_sink_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_BERTool_0_0_0_0_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>1</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>b_BERTool_0_0_0_0_0</source_block_id><sink_block_id>virtual_sink_0_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_u_M_PAM_bb_0</source_block_id><sink_block_id>e_mpam_ph</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_u_M_PAM_bb_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_u_M_PAM_bb_0_0</source_block_id><sink_block_id>e_mpam_ph_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_u_M_PAM_bb_0_0</source_block_id><sink_block_id>virtual_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_u_M_PAM_bb_0_0_0</source_block_id><sink_block_id>e_mpam_ph_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_u_M_PAM_bb_0_0_0</source_block_id><sink_block_id>virtual_sink_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_u_de_M_PAM_bb_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>b_u_de_M_PAM_bb_0</source_block_id><sink_block_id>virtual_sink_0_0_0_3_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_u_de_M_PAM_bb_0_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>b_u_de_M_PAM_bb_0_0</source_block_id><sink_block_id>virtual_sink_0_0_0_3_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_u_de_M_PAM_bb_0_0_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>b_u_de_M_PAM_bb_0_0_0</source_block_id><sink_block_id>virtual_sink_0_0_0_3_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_1</source_block_id><sink_block_id>b_BERTool_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0_1_0</source_block_id><sink_block_id>b_BERTool_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0_1_0_0</source_block_id><sink_block_id>b_BERTool_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>e_VCO_fase_fc_0</source_block_id><sink_block_id>virtual_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e_VCO_fase_fc_0_0</source_block_id><sink_block_id>virtual_sink_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e_VCO_fase_fc_0_0_0</source_block_id><sink_block_id>virtual_sink_0_0_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e_c_p</source_block_id><sink_block_id>e_phase</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e_c_p_0</source_block_id><sink_block_id>e_phase_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e_c_p_0_0</source_block_id><sink_block_id>e_phase_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e_mpam_ph</source_block_id><sink_block_id>e_VCO_fase_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e_mpam_ph_0</source_block_id><sink_block_id>e_VCO_fase_fc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e_mpam_ph_0_0</source_block_id><sink_block_id>e_VCO_fase_fc_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e_phase</source_block_id><sink_block_id>b_u_de_M_PAM_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e_phase</source_block_id><sink_block_id>virtual_sink_0_0_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e_phase_0</source_block_id><sink_block_id>b_u_de_M_PAM_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e_phase_0</source_block_id><sink_block_id>virtual_sink_0_0_0_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e_phase_0_0</source_block_id><sink_block_id>b_u_de_M_PAM_bb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>e_phase_0_0</source_block_id><sink_block_id>virtual_sink_0_0_0_3_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0_0</source_block_id><sink_block_id>b_BERTool_0_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>virtual_source_1_0_0_0</source_block_id><sink_block_id>blocks_delay_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0_0_0_0</source_block_id><sink_block_id>blocks_delay_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0_0_0_0_0</source_block_id><sink_block_id>blocks_delay_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0_0_1</source_block_id><sink_block_id>b_BERTool_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>virtual_source_1_0_0_1_0</source_block_id><sink_block_id>b_BERTool_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>e_c_p</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2_0</source_block_id><sink_block_id>b_BERTool_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2_0_0</source_block_id><sink_block_id>b_BERTool_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2_0_0_0</source_block_id><sink_block_id>b_BERTool_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2_1</source_block_id><sink_block_id>e_c_p_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2_1_0</source_block_id><sink_block_id>e_c_p_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
